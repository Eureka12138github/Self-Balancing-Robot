# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Config;.\Middlewares\Core;.\Middlewares\Third_Party;.\Test;.\App\cloud;.\App\ui\ui_framework;.\App\ui\ui_conten;.\App\log;.\App\storage;.\Core\Src;.\Core\Inc;.\Drivers\Communication;.\Drivers\Sensors;.\App\task;.\App\system;.\App\sensors;.\Library;.\System\stm32f103c8t6_minidev;.\Drivers\Input;.\Drivers\Display;.\Drivers\Display\Fonts;.\Utils\buffer;.\Utils\debug;.\Drivers\LED;.\Drivers\Output;.\Drivers\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/Src/: main.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s core_cm3.c
    ./Core/Inc/: stm32f10x_it.h system_stm32f10x.h stm32f10x.h stm32f10x_conf.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/stm32f103c8t6_minidev/: alarm.c alarm.h delay.c delay.h flash.c flash.h i2c.c i2c.h iwdg.c iwdg.h rtc.c rtc.h timer.c timer.h usart.c usart.h MyI2C.c MyI2C.h
  group Drivers
    ./Drivers/Sensors/: dht11.c dht11.h
    ./Drivers/Input/: key.c key.h rotary_encoder.c rotary_encoder.h RP.c RP.h hall_encoder.c hall_encoder.h
    ./Drivers/Display/Fonts/: OLED_Fonts.c OLED_Fonts.h
    ./Drivers/Display/: OLED.c OLED.h
    ./Drivers/LED/: LED.c LED.h
    ./Drivers/Output/: Motor.c Motor.h PWM.c PWM.h
    ./Drivers/IMU/: MPU6050.c MPU6050.h MPU6050_Reg.h
  group Utils
    ./Utils/buffer/: cbuf_slot.c cbuf_slot.h
    ./Utils/debug/: my_assert.c my_assert.h
  group APP
    ./App/system/: System_Init.c System_Init.h
    ./App/task/: task_sched.c task_sched.h
    ./App/storage/: storage.c storage.h
    ./App/sensors/: sensors_data.c sensors_data.h
    ./App/log/: error_warning_log.c error_warning_log.h
    ./App/ui/ui_framework/: menu.c menu.h menu_callbacks.c menu_callbacks.h menu_core_types.h
    ./App/ui/ui_conten/: menu_data.c menu_data.h
  group Config
    ./Config/: debug_config.h bsp_config.h system_config.c system_config.h
